options:
  parameters:
    generate_options: qt_gui
    id: lab4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: co
  id: variable_constellation
  parameters:
    const_points: (-0.707 -0.707j,-1+ 0j,0 + 1j,- 0.707 + 0.707j, 0-1j, 0.707 -0.707j, 0.707+0.707j,1-0j)
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: calcdist
  states: {}
- name: h
  id: variable
  parameters:
    value: '[ 1]*Sps'
  states: {}
- name: ruido
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: tabla_verdad_constelacion
  id: variable
  parameters:
    value: (-0.707 -0.707j,-1+ 0j,0 + 1j,- 0.707 + 0.707j, 0-1j, 0.707 -0.707j, 0.707+0.707j,1-0j)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '3'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '3'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '3'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '3'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/comu2lab5/cancion.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_verdad_constelacion
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: co
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: h
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Decod
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: Prueba
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: samp_rate
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: p0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p1
  states: {}

connections:
- [blocks_char_to_float_0, '0', audio_sink_0, '0']
- [blocks_float_to_char_0, '0', blocks_throttle_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [fir_filter_xxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1

options:
  parameters:
    generate_options: qt_gui
    id: Lab1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ff
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 0.1e6
    stop: 107e6
    value: 88e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 390.625e3
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk (gr. sync_block ):
      	def __init__ ( self ) : # only defau		lt arguments here
      		gr. sync_block . __init__ (
      			self ,
      			name ="Promedios_de_tiempos", # will show up in GRC
      			in_sig =[ np. float32 ],
      			out_sig =[ np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32 ]
      		)	
      		self . acum_anterior = 0
      		self . Ntotales = 0
      		self . acum_anterior1 = 0
      		self . acum_anterior2 = 0
      	def work (self , input_items , output_items ):
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Promedio de la senial
      		y1 = output_items [1] # Media de la senial
      		y2 = output_items [2] # RMS de la senial
      		y3 = output_items [3] # Potencia promedio de la senial
      		y4 = output_items [4] # Desviacion estandar de la senial
      		# Calculo del promedio
      		N = len (x)
      		self . Ntotales = self . Ntotales + N
      		acumulado = self . acum_anterior + np. cumsum (x)
      		self . acum_anterior = acumulado [N -1]
      		y0 [:]= acumulado / self . Ntotales
      		# Calculo de la media cuadratica
      		x2=np. multiply (x,x)
      		acumulado1 = self . acum_anterior1 + np. cumsum (x2)
      		self . acum_anterior1 = acumulado1 [N -1]
      		y1 [:] = acumulado1 / self . Ntotales
      		# Calculo de la RMS
      		y2 [:] = np. sqrt (y1)
      		# Calculo de la potencia promedio
      		y3 [:] = np. multiply (y2 ,y2)
      		# Calculo de la desviacion estandar
      		x3 = np. multiply (x-y0 ,x-y0)
      		acumulado2 = self . acum_anterior2 + np. cumsum (x3)
      		self . acum_anterior2 = acumulado2 [N -1]
      		y4 [:] = np. sqrt ( acumulado2 / self . Ntotales )
      		return len (x)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: ff
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Media cuadràtica
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: RMS
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Potencia promedio
    type: float
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: Desviaciòn
    type: float
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: ff
    gain0: gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_0, '0']
- [epy_block_0, '2', qtgui_number_sink_0_1, '0']
- [epy_block_0, '3', qtgui_number_sink_0_2, '0']
- [epy_block_0, '4', qtgui_number_sink_0_3, '0']
- [uhd_usrp_source_1, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1

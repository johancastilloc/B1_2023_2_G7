options:
  parameters:
    generate_options: qt_gui
    id: lab4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: co
  id: variable_constellation_rect
  parameters:
    const_points: (-0.707 -0.707j,-1+ 0j,0 + 1j,- 0.707 + 0.707j, 0-1j, 0.707 -0.707j, 0.707+0.707j,1-0j)
    imag_sect: '4'
    real_sect: '4'
    rot_sym: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: h
  id: variable
  parameters:
    value: '[ 1]*Sps'
  states: {}
- name: ruido
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: tabla_verdad_constelacion
  id: variable
  parameters:
    value: (-0.707 -0.707j,-1+ 0j,0 + 1j,- 0.707 + 0.707j, 0-1j, 0.707 -0.707j, 0.707+0.707j,1-0j)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '128'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.084'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.2'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '96000'
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '192000'
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '3'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '3'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/comu2lab5/cancion.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_verdad_constelacion
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: co
  states: {state: disabled}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.2'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.2'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '500000'
    decim: '1'
    gain: '1'
    samp_rate: '1000000'
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '64'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '4'
    type: fff
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: p1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p1
  states: {}

connections:
- [blocks_char_to_float_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_float_to_char_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', digital_psk_mod_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', low_pass_filter_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_psk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_psk_mod_0, '0', low_pass_filter_0, '0']
- [digital_psk_mod_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [rational_resampler_xxx_0_0_0, '0', digital_psk_demod_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_throttle_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1

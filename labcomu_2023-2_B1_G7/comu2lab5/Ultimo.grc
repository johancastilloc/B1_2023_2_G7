options:
  parameters:
    generate_options: qt_gui
    id: lab4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: co
  id: variable_constellation_rect
  parameters:
    const_points: tabla_verdad_constelacion
    imag_sect: '4'
    real_sect: '4'
    rot_sym: '8'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: escala
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '500'
    value: '128'
  states: {}
- name: gainrx
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: gaintx
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: h
  id: variable
  parameters:
    value: '[ 1]*Sps'
  states: {}
- name: portadora
  id: variable_qtgui_range
  parameters:
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 500e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: int(12500000/32)
  states: {}
- name: tabla_verdad_constelacion
  id: variable
  parameters:
    value: (-0.707 -0.707j,- 0.707 + 0.707j, 0.707 -0.707j, 0.707+0.707j)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: escala
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: escala
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/cancion.wav
    repeat: 'True'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: co
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: co
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Salida Rx"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Salida Tx"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: portadora
    fftsize: '1024'
    name: '"Entrada F"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: portadora
    fftsize: '1024'
    name: '"Salida Rx"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Salida total"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Entrada T"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: samp_rate
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 90e3
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 64e3
    center_freq0: portadora
    gain0: gaintx
    samp_rate: samp_rate2
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 90e3
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: '64000'
    center_freq0: portadora
    gain0: gainrx
    samp_rate: samp_rate2
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p1
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', audio_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_char_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', uhd_usrp_sink_0, '0']
- [digital_constellation_encoder_bc_0, '0', uhd_usrp_sink_1, '0']
- [digital_constellation_encoder_bc_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_0, '0']
- [uhd_usrp_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_1, '0', digital_constellation_decoder_cb_0, '0']
- [uhd_usrp_source_1, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
